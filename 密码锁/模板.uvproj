# Keil uVision project 模板.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: 模板 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 模板.c i2c.c delay.h delay.c
