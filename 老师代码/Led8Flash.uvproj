# Keil uVision project Led8Flash.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LedFlash +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Led7Seg.c uart.c Tick.c Key.c Task.c
